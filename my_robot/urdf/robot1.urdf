Commit message: 加入障碍物检测

File: my_robot/urdf/robot1.urdf (robot description, URDF)
Before this commit: robot single_wheel_robot, 3 links, 2 joints
Links:
- link lidar_link: geometry collision cylinder length=0.07 radius=0.03; visual cylinder length=0.07 radius=0.03
